# IAR project RTOS_project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8E Atmel SAM3X8E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RTOS_project.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\Users\erilid17\Desktop\redesignedProject\sam3x8-sram_BigHeap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: at91sam3x8.h context_switching_functions_march_2019.s core_cm3.h core_cmFunc.h core_cmInstr.h cstartup.s exceptions.c exceptions.h kernel_functions_march_2019.c kernel_functions_march_2019.h sample_test_one.c sample_test_two.c startup_sam3x.c system_sam3x.c system_sam3x.h test.c
